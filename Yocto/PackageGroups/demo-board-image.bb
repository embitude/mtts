SUMMARY = "Demo board production image"

IMAGE_FEATURES += "splash"

LICENSE = "MIT"

inherit core-image

